# Keil uVision project ble_ant_app_hrm_s310_pca10028.uvprojx, settings and files
target nrf51422_xxac_s310 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s310 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD BOARD_PCA10028 S310 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\bsp;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s310\headers;..\..\..\..\..\..\..\HUB_BOX\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\ant\ant_channel_config;..\..\..\..\..\..\components\softdevice\s310\headers;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\ant\ant_search_config;..\..\..\..\ble_ant_app_hrm
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002200 size 0x5e00
  group Application
    ../../../: main.c asc_master.c asc_device_registry.c asc_pages.c asc_master_to_master.c ble_phone_connection.c asc_coordinator.c ble_controllable_hub.c n5sk_button.c n5sk_led.c ant_phone_connection.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
    ../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../components/ant/ant_search_config/: ant_search_config.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
    ../../../../../../components/ble/ble_services/ble_hids/: ble_hids.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s310/doc/: s310_nrf51822_3.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
target flash_s310_nrf51422_3.0.0_softdevice (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: s310_nrf51422_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
